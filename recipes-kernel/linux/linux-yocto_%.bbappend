FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-enable-uart.patch file://serial_dev_bus.cfg"
